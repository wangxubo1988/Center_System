# Keil uVision project center_freertos_stm32f207.uvproj, settings and files
target center_freertos_stm32f207 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: center_freertos_stm32f207 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./update.bin ./STM322xG_EVAL/center_freertos_stm32f207.axf
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_DEBUG
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F2x7_ETH_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Utilities\Third_Party\lwip\src\include;..\..\..\Utilities\Third_Party\lwip\src\include\lwip;..\..\..\Utilities\Third_Party\lwip\src\include\netif;..\..\..\Utilities\Third_Party\lwip\src\include\ipv4;..\..\..\Utilities\Third_Party\lwip\port\STM32F2x7;..\..\..\Utilities\Third_Party\lwip\port\STM32F2x7\FreeRTOS;..\..\..\Utilities\Third_Party\FreeRTOS\include;..\..\..\Utilities\Third_Party\FreeRTOS\portable\MDK-ARM\ARM_CM3;..\..\..\Utilities\Third_Party\FatFs;..\..\..\Libraries\Encrypt
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
  group User
    ../src/: main.c stm32f2xx_it.c usart_dma.c usr_cpu.c usr_sd.c main_time.c flash.c Usart3_Debug.c usr_api.c usr_bsp.c usr_net.c net_server.c update_program.c
  group LwIP
    ../../../Utilities/Third_Party/lwip/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c def.c
    ../../../Utilities/Third_Party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/Third_Party/lwip/src/netif/: etharp.c loopif.c slipif.c
    ../../../Utilities/Third_Party/lwip/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
    ../../../Utilities/Third_Party/lwip/src/api/: tcpip.c
    ../../../Utilities/Third_Party/lwip/port/: server.c helloworld.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_dma.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_usart.c misc.c stm32f2xx_syscfg.c stm32f2xx_flash.c stm32f2xx_rtc.c stm32f2xx_exti.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_iwdg.c stm32f2xx_rng.c
  group STM32F2x7_ETH_Driver
    ../../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c stm32f2x7_eth_bsp.c
  group STM322xG_EVAL
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOS/: croutine.c list.c queue.c tasks.c
    ../../../Utilities/Third_Party/FreeRTOS/portable/MDK-ARM/ARM_CM3/: port.c
    ../../../Utilities/Third_Party/FreeRTOS/portable/MemMang/: heap_2.c
  group FAT/FS
    ../../../Utilities/Third_Party/FatFs/: diskio.c ff.c
  group Encrypt
    ../../../Libraries/Encrypt/: aes.c md5.c sha1.c
