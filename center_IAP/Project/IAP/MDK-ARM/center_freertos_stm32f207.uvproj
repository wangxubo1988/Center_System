# Keil uVision project center_freertos_stm32f207.uvproj, settings and files
target center_iap (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: center_IAP +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Utilities\Third_Party\FatFs;..\..\..\Utilities\iap;..\..\..\Utilities\stmflash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
  group User
    ../src/: main.c stm32f2xx_it.c update_program.c md5.c flash.c usr_flash.c usr_sd.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_dma.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_usart.c misc.c stm32f2xx_syscfg.c stm32f2xx_flash.c stm32f2xx_rtc.c stm32f2xx_exti.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_iwdg.c
  group STM322xG_EVAL
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group Fat/Fs
    ../../../Utilities/Third_Party/FatFs/: diskio.c ff.c
